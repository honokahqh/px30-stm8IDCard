# IAR project Backup (2) of ZK_Draven.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\APP; ..\BSP; ..\STM8S_Driver\inc; ..\ProtoOS; ..\MB_Slaver; ..\MB_Slaver\PhysicalDrive
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ZK_Draven.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    ../APP/: app.c app.h appValue.c appValue.h main.c stm8s.h stm8s_conf.h stm8s_exti.c stm8s_exti.h stm8s_gpio.c stm8s_gpio.h stm8s_tim2.c stm8s_tim2.h upData.c upData.h
  group BSP
    ../BSP/: bsp.c bsp.h bsp_clock.c bsp_clock.h bsp_dog.c bsp_dog.h bsp_Manchester.c bsp_Manchester.H bsp_rgb.c bsp_rgb.h bsp_stEEPROM.c bsp_stEEPROM.h
  group Modbus
    ../MB_Slaver/: MBS_Core.c MBS_Function.c MBS_Map.c MBS_Memory.c MBS_Physical.c MBS_Port.c MBS_Str.c MBS_User.c modbusSlaver.h
    ../MB_Slaver/PhysicalDrive/: STM8usart1.c STM8usart1.h
  group RTOS
    ../ProtoOS/: lc-addrlabels.h lc-switch.h lc.h pt-sem.h pt.h
